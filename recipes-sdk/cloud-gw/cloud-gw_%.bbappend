S32N_SDK_DIR ??= "."