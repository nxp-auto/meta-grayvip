S32N_SDK_DIR ??= "."
MOTIONWISE_COMMUNICATION_EK_DIR ??= "${S32N_SDK_DIR}/prebuilt/${MOTIONWISE_COMMUNICATION_EK}"
