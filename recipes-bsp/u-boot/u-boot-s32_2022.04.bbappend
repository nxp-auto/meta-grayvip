FILESEXTRAPATHS:prepend := "${THISDIR}/${BPN}:"
SRC_URI += " \
    file://0001-s32n79-env-Disable-SMMU-and-enable-APS-MRU-msi-contr.patch \
"
