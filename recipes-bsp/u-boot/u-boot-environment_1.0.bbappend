# Copyright 2025-2026 NXP

FILESEXTRAPATHS:prepend:fsl-grayvip-qnx := "${THISDIR}/${BPN}/grayvip-qnx:"
