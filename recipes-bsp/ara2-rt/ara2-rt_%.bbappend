# Workaround to avoid failures in fetching the "ara2-sdk-r2.1-lic.tar" when the
# package is not included.
ARA_RT_URL ??= "https://dummy.com"