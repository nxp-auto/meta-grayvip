# Copyright 2026 NXP

CARVCE_PLATFORM_CFLAGS = ""
CARVCE_PLATFORM_CFLAGS:s32n79sim = "-DCARVCE_PLATFORM_TYPE_VDK=1"
CARVCE_PLATFORM_CFLAGS:s32n79rdb = "-DCARVCE_PLATFORM_TYPE_RDB=1"

EXTRA_OEMAKE = "PREFIX=${CARV_ROOT} LIBDIR=${CARV_LIB} INCLUDEDIR=${CARV_INCLUDE} CC='${CC} ${CARVCE_PLATFORM_CFLAGS}' DESTDIR=${D} O=${B}"