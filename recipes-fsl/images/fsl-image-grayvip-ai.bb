# Copyright 2026 NXP

DESCRIPTION = "GrayVIP Yocto Image with Ubuntu support"

require recipes-fsl/images/fsl-image-grayvip-base-ubuntu.inc